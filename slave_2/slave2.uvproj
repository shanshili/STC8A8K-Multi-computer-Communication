# Keil uVision project slave2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: slave2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\Keil_v5\C51\INC\INTRINS.H
  group Source Group 1
    ./: STARTUP.A51 delay.c slave2_2.c
